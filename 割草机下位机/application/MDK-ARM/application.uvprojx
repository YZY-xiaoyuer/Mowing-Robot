# Keil uVision project application.uvprojx, settings and files
target application (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: application +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;..\shell;..\car;..\eMPL;..\MOTOR;..\PID;..\speed;..\wheel;..\Data;..\BON055;..\GPS;..\UART3;..\TIME;..\CRC;..\protocol;..\Queue;..\Upper_cmd
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../TIME/: time.c
    ../Src/: main.c gpio.c dma.c freertos.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group shell
    ../shell/: shell.c usercmd.c
  group IMU
    ../eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group BNO055
    ../BON055/: BNO005.c BNO005.h
  group GPS
    ../GPS/: gps.c gps.h
  group MOTOR
    ../MOTOR/: MOTOR_driver.h MOTOR_driver.c
  group SPEED
    ../speed/: speed.c speed.h
  group WHEEL
    ../wheel/: wheel.c wheel.h
  group CAR
    ../car/: car.h car.c
  group PID
    ../PID/: pid.h pid.c
  group DATA
    ../Data/: data.c data.h
  group CRC
    ../CRC/: crc.c crc.h
  group PROTOCOL
    ../protocol/: protocol.c protocol.h
  group QUEUE
    ../Queue/: uart3_rcv_queue.c uart3_rcv_queue.h
  group UART_IDL
    ../UART3/: uart.h uart.c
  group UPPER_CMD
    ../Upper_cmd/: uppercmd.c uppercmd.h
software components: CMSIS:CORE 4.3.0
